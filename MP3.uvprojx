# Keil uVision project MP3.uvprojx, settings and files
target MP3 (6160000::V6.16::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MP3
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HSE_VALUE=8000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MAIN
    ./: main.c stm32f4xx_it.c
  group MP3
    ./: mp3.c mp3.h
  group JOYSTICK
    ./: joystick.c joystick.h
  group LCD
    ./: Arial12x12.h lcd.c lcd.h
  group PWM
    ./: pwm.c pwm.h
  group RGB
    ./: rgb.c rgb.h
  group POT_2
    ./: pot.c pot.h adc.c adc.h
  group HORA
    ./: clock.c clock.h
  group TEMPERATURA
    ./: temp.h Thread_Temp.c
  group COM_PC
    ./: com.c com.h
  group HILO_PRINCIPAL
    ./: Principal.c Principal.h
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, CMSIS Driver:I2C 2.10, CMSIS Driver:SPI 2.15, CMSIS Driver:USART 2.13, Device:STM32Cube Framework:Classic 1.7.9, Device:STM32Cube HAL:ADC 1.7.9, Device:STM32Cube HAL:Common 1.7.9, Device:STM32Cube HAL:Cortex 1.7.9, Device:STM32Cube HAL:DMA 1.7.9, Device:STM32Cube HAL:GPIO 1.7.9, Device:STM32Cube HAL:I2C 1.7.9, Device:STM32Cube HAL:PWR 1.7.9, Device:STM32Cube HAL:RCC 1.7.9, Device:STM32Cube HAL:SPI 1.7.9, Device:STM32Cube HAL:TIM 1.7.9, Device:STM32Cube HAL:USART 1.7.9, Device:Startup 2.6.3
